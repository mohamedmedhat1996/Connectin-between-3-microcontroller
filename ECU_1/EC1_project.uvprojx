# Keil uVision project EC1_project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EC1_project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99
  c include: D:\tivaware
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Source Group 1
    ./: main.c My_Tasks.c My_Tasks.h
    C:/Users/mm/Videos/midterm/EC1/EC1_updated/: can_rx.c can_rx.h console.c console.h Dio_IntPin.c Dio_IntPin.h lamp.c lamp.h lighting.c lighting.h state_receiver.c state_receiver.h switch_interput.c switch_interput.h
  group library
    D:/tivaware/driverlib/rvmdk/: driverlib.lib
    D:/tivaware/utils/: uartstdio.h uartstdio.c
    D:/tivaware/driverlib/: can.c can.h gpio.c gpio.h pin_map.h
software components: RTOS:Config 10.3.1, RTOS:Core 10.3.1, RTOS:Heap 10.3.1, RTOS:Timers 10.3.1, CMSIS:CORE 5.4.0, Device:Startup 1.0.1
